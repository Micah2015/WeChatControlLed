# Keil uVision project STM32F103VE Wifi.uvprojx, settings and files
target STM32F103VE Wifi (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\Lib\inc;..\Lib\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c stm32f10x_conf.h led30.c tim3.c usart1.c global.h
  group Lib
    ../Lib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c misc.c stm32f10x_usart.c
  group StartupCode
    ../CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
